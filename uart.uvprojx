# Keil uVision project uart.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: uart +hex
  c flags: Optim=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F429_439xx,USE_DEFAULT_TIMEOUT_CALLBACK
  c include: .\CMSIS\include;.\STM32F4xx_StdPeriph_Driver\include;.\User\include;.\Utilities\Common;.\Utilities\STM32F429I-Discovery
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMSIS
    ./CMSIS/src/: system_stm32f4xx.c startup_stm32f429_439xx.s
  group STM32F4xx_StdPeriph_Driver
    ./STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_fmc.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_ltdc.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_usart.c misc.c
  group User
    ./User/src/: main.c
  group STM32F429I-Discovery
    ./Utilities/STM32F429I-Discovery/: stm32f429i_discovery.c stm32f429i_discovery_i2c_ee.c stm32f429i_discovery_ioe.c stm32f429i_discovery_l3gd20.c stm32f429i_discovery_lcd.c stm32f429i_discovery_sdram.c
